# IAR project Bootloader.ewp, settings and files
configuration Flash Debug K60 (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx12 Freescale MK60FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa082,Pe191,Pe186,Pe550,Pe177,Pa039,Pe223
  ICCARM.CCIncludePath2: ; APP; BSP; BSP\PE; USB_CLASS; USB_DRIVER
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ; ..\..\; ..\..\flash_driver; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  OBJCOPY.OOCOutputFile: Bootloader.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    APP/: aes.c aeskeys.c CAN_task.c Diagnostic_print.c flash_FTFL.c Main.c md5.c usb_descriptor.c USB_task.c USB_timer.c Y_Loader.c
  group BSP
    BSP/: CAN_control.c GPIO.c LCD_control.c low_level_init.c PIT.c printf.c Sdelay.S startup.s UART.c vector_tbl.s VIC.c
  group BSP/PE
    BSP/PE/: Cpu.c
  group USB_CLASS
    USB_CLASS/: usb_class.c usb_dfu.c usb_hid.c
  group USB_DRIVER
    USB_DRIVER/: usb_dci_kinetis.c usb_driver.c usb_framework.c
