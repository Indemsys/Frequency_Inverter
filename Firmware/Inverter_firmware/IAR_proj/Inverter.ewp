# IAR project Inverter.ewp, settings and files
configuration DEBUG_BOOTABLE (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx12 Freescale MK60FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../mqx/source/tad; ../mqx/source/psp/cortex_m/cpu; ../mqx/source/psp/cortex_m/core/M4; ../mqx/source/psp/cortex_m/compiler/iar; ../mqx/source/psp/cortex_m; ../mqx/source/io/usb_dcd/polled; ../mqx/source/io/usb_dcd/int; ../mqx/source/io/usb_dcd; ../mqx/source/io/usb; ../mqx/source/io/timer; ../mqx/source/io/tfs; ../mqx/source/io/tchres; ../mqx/source/io/spi; ../mqx/source/io/serial; ../mqx/source/io/sdcard/sdcard_spi; ../mqx/source/io/sdcard/sdcard_esdhc; ../mqx/source/io/sdcard; ../mqx/source/io/sai/int; ../mqx/source/io/sai; ../mqx/source/io/rtc; ../mqx/source/io/pipe; ../mqx/source/io/pcflash; ../mqx/source/io/pccard; ../mqx/source/io/pcb/mqxa; ../mqx/source/io/pcb; ../mqx/source/io/nandflash/nfc; ../mqx/source/io/nandflash; ../mqx/source/io/lwgpio; ../mqx/source/io/lpm; ../mqx/source/io/io_null; ../mqx/source/io/io_mem; ../mqx/source/io/io_dun; ../mqx/source/io/i2c/polled; ../mqx/source/io/i2c/int; ../mqx/source/io/i2c; ../mqx/source/io/hwtimer; ../mqx/source/io/gpio/kgpio; ../mqx/source/io/gpio; ../mqx/source/io/flashx/freescale; ../mqx/source/io/flashx; ../mqx/source/io/esdhc; ../mqx/source/io/enet/phy; ../mqx/source/io/enet/macnet; ../mqx/source/io/enet; ../mqx/source/io/debug; ../mqx/source/io/crc; ../mqx/source/io/cm; ../mqx/source/io/can/flexcan; ../mqx/source/io/adc/kadc; ../mqx/source/io/adc; ../mqx/source/include; ../mqx/source/bsp/INV1_K60F120; ../mqx/source/bsp/INV1_K60F120/PE; ../mqx/source/bsp/INV1_K60F120/PE/INC_PDD; ../config/INV1_K60F120; ../config/common; ../MotorControlLib; ../MotorControlLib/GDFLIB; ../MotorControlLib/GFLIB; ../MotorControlLib/GMCLIB
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../mqx/source/tad; ../mqx/source/psp/cortex_m/cpu; ../mqx/source/psp/cortex_m/core/M4; ../mqx/source/psp/cortex_m/compiler/iar; ../mqx/source/psp/cortex_m; ../mqx/source/io/usb_dcd/polled; ../mqx/source/io/usb_dcd/int; ../mqx/source/io/usb_dcd; ../mqx/source/io/usb; ../mqx/source/io/timer; ../mqx/source/io/tfs; ../mqx/source/io/tchres; ../mqx/source/io/spi; ../mqx/source/io/serial; ../mqx/source/io/sdcard/sdcard_spi; ../mqx/source/io/sdcard/sdcard_esdhc; ../mqx/source/io/sdcard; ../mqx/source/io/sai/int; ../mqx/source/io/sai; ../mqx/source/io/rtc; ../mqx/source/io/pipe; ../mqx/source/io/pcflash; ../mqx/source/io/pccard; ../mqx/source/io/pcb/mqxa; ../mqx/source/io/pcb; ../mqx/source/io/nandflash/nfc; ../mqx/source/io/nandflash; ../mqx/source/io/lwgpio; ../mqx/source/io/lpm; ../mqx/source/io/io_null; ../mqx/source/io/io_mem; ../mqx/source/io/io_dun; ../mqx/source/io/i2c/polled; ../mqx/source/io/i2c/int; ../mqx/source/io/i2c; ../mqx/source/io/hwtimer; ../mqx/source/io/gpio/kgpio; ../mqx/source/io/gpio; ../mqx/source/io/flashx/freescale; ../mqx/source/io/flashx; ../mqx/source/io/esdhc; ../mqx/source/io/enet/phy; ../mqx/source/io/enet/macnet; ../mqx/source/io/enet; ../mqx/source/io/debug; ../mqx/source/io/crc; ../mqx/source/io/cm; ../mqx/source/io/can/flexcan; ../mqx/source/io/adc/kadc; ../mqx/source/io/adc; ../mqx/source/include; ../mqx/source/bsp/INV1_K60F120; ../config/INV1_K60F120; ../config/common
  OBJCOPY.OOCOutputFile: Firmware_image.hex
  ILINK.IlinkOutputFile: Firmware_image.out
  ILINK.IlinkIcfFile: INT_FLASH_W_BOOT.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../mqx/source/bsp/INV1_K60F120/: bsp.h bsp_cm.c bsp_cm.h bsp_prv.h bsp_rev.h init_adc.c init_bsp.c init_cfcard.c init_enet.c init_esdhc.c init_flashx.c init_gpio.c init_hw.c init_i2c.c init_iodebug.c init_lpm.c init_lpm.h init_nandflash.c init_sai.c init_sci.c init_sdcard.c init_spi.c init_tchres.c init_usb.c init_usb_dcd.c INV1_K60F120.h mqx_init.c mqx_main.c PE_LDD.h PE_Types.h vectors.c
    ../mqx/source/io/enet/: enet.h enet_wifi.h ethernet.h
    ../config/common/: maximum_config.h small_ram_config.h smallest_config.h verif_enabled_config.h
    ../mqx/source/include/: mqx.h
  group Config
    ../config/INV1_K60F120/: user_config.h
  group Generic IO Drivers/cm
    ../mqx/source/io/cm/: cm.c cm.h cm_kinetis.h
  group Generic IO Drivers/debug
    ../mqx/source/io/debug/: iodebug.c iodebug.h iodebug_asm.S iodebug_prv.h
  group Generic IO Drivers/io_dun
    ../mqx/source/io/io_dun/: io_dun.c io_dun.h
  group Generic IO Drivers/io_mem
    ../mqx/source/io/io_mem/: io_mem.c io_mem.h iomemprv.h
  group Generic IO Drivers/io_null
    ../mqx/source/io/io_null/: io_null.c io_null.h ionulprv.h
  group Generic IO Drivers/iopipe
    ../mqx/source/io/pipe/: io_pipe.c io_pipe.h pipe_prv.h
  group Generic IO Drivers/lpm
    ../mqx/source/io/lpm/: lpm.c lpm.h lpm_kinetis.h lpm_prv.h lpm_smc.c
  group Generic IO Drivers/pcb
    ../mqx/source/io/pcb/: io_pcb.c io_pcb.h io_pcb2.c iop_inst.c iopcbprv.h
    ../mqx/source/io/pcb/mqxa/: pcb_mqxa.c pcb_mqxa.h pcbmqxav.h
  group Generic IO Drivers/tfs
    ../mqx/source/io/tfs/: tfs.c tfs.h tfs_prv.h
  group Main
    ../Main/: ADC_control.c CAN_control.c LCD_control.c Main.c MonitorVT100.c Motor_control.c Pins_control.c Sdelay.S Sin_Cos_generator.c Temperature_control.c Tests.c VIC_control.c
  group MotorControlLib
    ../MotorControlLib/: Cortex_M4_IAR.a gdflib.h gflib.h gmclib.h intrinsic_cw.h SWLIBS_Defines.h SWLIBS_Inlines.h SWLIBS_Typedefs.h
  group MotorControlLib/GDFLIB
    ../MotorControlLib/GDFLIB/: GDFLIB_FilterFIR.h GDFLIB_FilterIIR1.h GDFLIB_FilterIIR2.h GDFLIB_FilterMA.h
  group MotorControlLib/GFLIB
    ../MotorControlLib/GFLIB/: GFLIB_Acos.h GFLIB_Asin.h GFLIB_Atan.h GFLIB_AtanYX.h GFLIB_AtanYXShifted.h GFLIB_ControllerPIp.h GFLIB_ControllerPIpAW.h GFLIB_ControllerPIr.h GFLIB_Cos.h GFLIB_Hyst.h GFLIB_IntegratorTR.h GFLIB_Limit.h GFLIB_LowerLimit.h GFLIB_Lut1D.h GFLIB_Ramp.h GFLIB_Sign.h GFLIB_Sin.h GFLIB_Sqrt.h GFLIB_Tan.h GFLIB_UpperLimit.h
  group MotorControlLib/GMCLIB
    ../MotorControlLib/GMCLIB/: GMCLIB_Clark.h GMCLIB_ClarkInv.h GMCLIB_DecouplingPMSM.h GMCLIB_ElimDcBusRip.h GMCLIB_Park.h GMCLIB_ParkInv.h GMCLIB_SvmStd.h GMCLIB_VectorLimit.h
  group Peripheral IO Drivers/adc
    ../mqx/source/io/adc/: adc.c adc.h adc_conf.h adc_prv.h
    ../mqx/source/io/adc/kadc/: adc_mk60.c adc_mk60.h
  group Peripheral IO Drivers/adc/kadc
    ../mqx/source/io/adc/kadc/: adc_kadc.c adc_kadc.h adc_kadc_prv.h adt_kpdb.c
  group Peripheral IO Drivers/crc
    ../mqx/source/io/crc/: crc_kn.c crc_kn.h
  group Peripheral IO Drivers/enet
    ../mqx/source/io/enet/: enaddr.c enclose.c enerr.c enet_rev.h enetprv.h eninit.c enjoin.c enleave.c enmediactl.c enopen.c enrecv.c ensend.c enstat.c enstop.c enutil.c
    ../mqx/source/io/enet/macnet/: macnet_mk60.c macnet_mk60.h
  group Peripheral IO Drivers/enet/macnet
    ../mqx/source/io/enet/macnet/: macnet_1588.c macnet_1588.h macnet_init.c macnet_join.c macnet_mii.c macnet_prv.h macnet_receive.c macnet_rejoin.c macnet_rev.h macnet_send.c macnet_stop.c macnet_util.c
  group Peripheral IO Drivers/enet/phy
    ../mqx/source/io/enet/phy/: phy_ksz8041.c phy_ksz8041.h
  group Peripheral IO Drivers/esdhc
    ../mqx/source/io/esdhc/: esdhc.c esdhc.h esdhc_mk60.c esdhc_prv.h
  group Peripheral IO Drivers/flashx
    ../mqx/source/io/flashx/freescale/: flash_mk60.c flash_mk60.h
    ../mqx/source/io/flashx/: flashx.c flashx.h flashxprv.h
  group Peripheral IO Drivers/flashx/freescale
    ../mqx/source/io/flashx/freescale/: flash_ftfe.c flash_ftfe.h flash_ftfe_prv.h
  group Peripheral IO Drivers/flexcan
    ../mqx/source/io/can/flexcan/: flexcan_mk60.c kflexcan.c kflexcan.h kflexcan_int.c
  group Peripheral IO Drivers/gpio
    ../mqx/source/io/gpio/: io_gpio.c io_gpio.h io_gpio_prv.h
  group Peripheral IO Drivers/gpio/knxx
    ../mqx/source/io/gpio/kgpio/: io_gpio_kgpio.c io_gpio_kgpio.h io_gpio_kgpio_prv.h
  group Peripheral IO Drivers/hwtimer
    ../mqx/source/io/hwtimer/: hwtimer.c hwtimer.h hwtimer_kinetis.c hwtimer_pit.c hwtimer_pit.h
  group Peripheral IO Drivers/i2c
    ../mqx/source/io/i2c/: i2c.h i2c_ki2c.h i2c_ki2c_prv.h i2c_mk60.c
    ../mqx/source/io/i2c/int/: i2c_int_ki2c.c
    ../mqx/source/io/i2c/polled/: i2c_pol_ki2c.c
  group Peripheral IO Drivers/i2c/int
    ../mqx/source/io/i2c/int/: i2c_int.c i2c_int_prv.h
  group Peripheral IO Drivers/i2c/polled
    ../mqx/source/io/i2c/polled/: i2c_pol.c i2c_pol_prv.h
  group Peripheral IO Drivers/lwgpio
    ../mqx/source/io/lwgpio/: lwgpio.c lwgpio.h
  group Peripheral IO Drivers/lwgpio/kgpio
    ../mqx/source/io/lwgpio/: lwgpio_kgpio.c lwgpio_kgpio.h
  group Peripheral IO Drivers/nandflash
    ../mqx/source/io/nandflash/nand_devices/: MT29F2G16.c
    ../mqx/source/io/nandflash/: nandflash.c nandflash.h nandflashprv.h
    ../mqx/source/io/nandflash/nfc/: nfc.c nfc.h nfc_k60f120m.c
  group Peripheral IO Drivers/pccard
    ../mqx/source/io/pccard/: apccard.h pccardflexbus.c pccardflexbus.h pccardflexbuspr.h
  group Peripheral IO Drivers/pcflash
    ../mqx/source/io/pcflash/: apcflash.c apcflshpr.h ata.h pcflash.h
  group Peripheral IO Drivers/rtc
    ../mqx/source/io/rtc/: krtc.c krtc.h krtc_ext.c krtc_ext.h rtc.h
  group Peripheral IO Drivers/sai
    ../mqx/source/io/sai/: sai.h sai_ksai.h sai_ksai_prv.h sai_mk60.c
  group Peripheral IO Drivers/sai/int
    ../mqx/source/io/sai/int/: sai_int.c sai_int_ksai.c sai_int_prv.h
  group Peripheral IO Drivers/sdcard
    ../mqx/source/io/sdcard/: sdcard.c sdcard.h sdcard_prv.h
  group Peripheral IO Drivers/sdcard/sdcard_esdhc
    ../mqx/source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.c sdcard_esdhc.h
  group Peripheral IO Drivers/sdcard/sdcard_spi
    ../mqx/source/io/sdcard/sdcard_spi/: sdcard_spi.c sdcard_spi.h
  group Peripheral IO Drivers/serial
    ../mqx/source/io/serial/: io_sinit.c serial.h serinprv.h serl_kuart.h serl_mk60.c serplprv.h
  group Peripheral IO Drivers/serial/int
    ../mqx/source/io/serial/int/: serl_int.c serl_int_kuart.c
  group Peripheral IO Drivers/serial/polled
    ../mqx/source/io/serial/polled/: serl_pol.c serl_pol_kuart.c
  group Peripheral IO Drivers/spi
    ../mqx/source/io/spi/: spi.c spi.h spi_dspi.c spi_dspi.h spi_dspi_prv.h spi_mk60.c spi_prv.h
  group Peripheral IO Drivers/tchres
    ../mqx/source/io/tchres/: tchres.c tchres.h tchres_prv.h
  group Peripheral IO Drivers/timer
    ../mqx/source/io/timer/: qpit.h timer_kinetis.c timer_lpt.c timer_lpt.h timer_lpt_kinetis.c timer_qpit.c timer_qpit.h
  group Peripheral IO Drivers/usb
    ../mqx/source/io/usb/: if_dev_ehci.h if_dev_khci.h if_host_ehci.h if_host_khci.h usb_bsp.h usb_install.c usb_mk60f.c usb_mk60f_device.c
  group Peripheral IO Drivers/usb_dcc
    ../mqx/source/io/usb_dcd/: usb_dcd.h usb_dcd_kn.h usb_dcd_kn_prv.h usb_dcd_mk60.c
  group Peripheral IO Drivers/usb_dcc/int
    ../mqx/source/io/usb_dcd/int/: usb_dcd_int.c usb_dcd_int_kn.c usb_dcd_int_prv.h
  group Peripheral IO Drivers/usb_dcc/polled
    ../mqx/source/io/usb_dcd/polled/: usb_dcd_pol.c usb_dcd_pol_kn.c usb_dcd_pol_prv.h
  group ProcessorExpert
    ../mqx/source/bsp/INV1_K60F120/PE/: Cpu.c Cpu.h Events.c Events.h FTM0.c FTM0.h IO_Map.h MQX1.c MQX1.h PE_Const.h PE_Error.h PE_LDD.c PE_LDD.h PE_Types.h UART0.c UART0.h
  group ProcessorExpert/INC_PDD
    ../mqx/source/bsp/INV1_K60F120/PE/INC_PDD/: ADC_PDD.h CAN_PDD.h CMP_PDD.h CMT_PDD.h COP_PDD.h CRC_PDD.h DAC_PDD.h DMA_PDD.h DMAMUX_PDD.h DRY_PDD.h ENET_PDD.h EWM_PDD.h FMC_PDD.h FTFA_PDD.h FTFE_PDD.h FTFL_PDD.h FTM_PDD.h GPIO_PDD.h I2C_PDD.h I2S_PDD.h LCD_PDD.h LCDC_PDD.h LPTMR_PDD.h MCM_PDD.h NFC_PDD.h PDD_Types.h PIT_PDD.h PORT_PDD.h RNG_PDD.h RNGA_PDD.h RTC_PDD.h SAI_PDD.h SDHC_PDD.h SIM_PDD.h SPI_PDD.h SysTick_PDD.h TPM_PDD.h TSI_PDD.h UART0_PDD.h UART_PDD.h UARTLP_PDD.h USB_PDD.h USBHS_PDD.h WDOG_PDD.h
  group PSP Cortex
    ../mqx/source/psp/cortex_m/core/M4/: boot.S dispatch.S
    ../mqx/source/psp/cortex_m/: cache.c cortex.c cortex.h int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c kinetis.h kinetis_mpu.c kinetis_mpu.h mem_copy.c mem_zero.c nvic.c nvic.h psp.h psp_abi.h psp_comp.h psp_cpu.h psp_cpudef.h psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_math.h psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_prv.h psp_psti.c psp_rev.h psp_seti.c psp_supp.c psp_supp.h psp_tiad.c psp_tida.c psp_tihr.c psp_time.h psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tixd.c psp_tkti.c psp_usti.c psptypes.h sc_irdyq.c stack_bu.c stack_de.c stack_st.c
    ../mqx/source/psp/cortex_m/cpu/: kinetis_fcan.h MK60F15.h
  group PSP Cortex/compiler
    ../mqx/source/psp/cortex_m/compiler/iar/: asm_mac.h comp.c comp.h kernel_symbols.S
  group PSP Generic/fio
    ../mqx/source/fio/: io_clre.c io_dopr.c io_fclos.c io_feof.c io_ferr.c io_fflsh.c io_fgetc.c io_fgetl.c io_fgets.c io_fopen.c io_fp.c io_fprt.c io_fputc.c io_fputs.c io_fscan.c io_fseek.c io_fstat.c io_ftell.c io_fung.c io_ioctl.c io_misc.c io_pntf.c io_read.c io_scanf.c io_scanl.c io_spr.c io_sscan.c io_util.c io_vpr.c io_write.c
  group PSP Generic/include
    ../mqx/source/include/: charq.h eds.h eds_prv.h edserial.h edserprv.h event.h event_prv.h fio.h fio_prv.h fpio_prv.h gen_rev.h io.h io_prv.h io_rev.h ioctl.h ipc.h ipc_pcb.h ipc_pcbv.h ipc_prv.h ipcrtprv.h klog.h log.h log_prv.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwsem.h lwtimer.h lwtimer_prv.h mem_prv.h message.h mmu.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_macros.h mqx_prv.h mqx_str.h msg_prv.h mutex.h mutex_prv.h name.h name_prv.h partition.h partition_prv.h pcb.h posix.h queue.h sem.h sem_prv.h timer.h timer_prv.h watchdog.h watchdog_prv.h
  group PSP Generic/io
    ../mqx/source/io/: io_ghand.c io_init.c io_inst.c io_instx.c io_shand.c io_uinst.c
  group PSP Generic/kernel
    ../mqx/source/kernel/: event.c idletask.c int.c ipc.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwsem.c lwtimer.c mem.c mqx.c msg.c msgpool.c msgq.c mutex.c name.c partition.c queue.c sched.c sem.c task.c taskq.c time.c time_tables.c timer.c watchdog.c
  group PSP Generic/string
    ../mqx/source/string/: str_utos.c strnlen.c
  group PSP Generic/tad
    ../mqx/source/tad/: tad.c tad.h
