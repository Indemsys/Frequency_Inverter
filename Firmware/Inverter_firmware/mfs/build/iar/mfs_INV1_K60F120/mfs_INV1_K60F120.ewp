# IAR project mfs_INV1_K60F120.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../../../../mqx/source/tad; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/io/usb_dcd/polled; ../../../../mqx/source/io/usb_dcd/int; ../../../../mqx/source/io/usb_dcd; ../../../../mqx/source/io/usb; ../../../../mqx/source/io/timer; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/tchres; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/sai/int; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/pcflash; ../../../../mqx/source/io/pccard; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/nandflash/nfc; ../../../../mqx/source/io/nandflash; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_dun; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/gpio/kgpio; ../../../../mqx/source/io/gpio; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/esdhc; ../../../../mqx/source/io/enet/phy; ../../../../mqx/source/io/enet/macnet; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/debug; ../../../../mqx/source/io/crc; ../../../../mqx/source/io/cm; ../../../../mqx/source/io/can/flexcan; ../../../../mqx/source/io/adc/kadc; ../../../../mqx/source/io/adc; ../../../../mqx/source/include; ../../../../mqx/source/bsp/INV1_K60F120; ../../../../mfs/source/include; ../../../../config/INV1_K60F120; ../../../../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  postbuild: "../../../../mfs/build/bat/mfs_INV1_K60F120.bat" "../../../.." "../../../../lib/INV1_K60F120.iar/debug/mfs" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../mfs/build/bat/mfs_INV1_K60F120.bat" "../../../.." "../../../../lib/INV1_K60F120.iar/release/mfs" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group MFS Source
    ../../../../mfs/source/generic/: mfs_delete.c mfs_read.c mfs_init.c mfs_attribute.c mfs_dir_entry.c mfs_open.c mfs_handle.c mfs_search.c mfs_rw.c mfs_lfn.c part_mgr.c mfs_valdev.c mfs_parse.c mfs_write.c mfs_data_sector.c mfs_cluster.c mfs_directory.c mfs_rename.c dir_read.c mfs_misc.c mfs_create.c mfs_format.c mfs_fat.c mfs_time.c
  group MFS Include
    ../../../../mfs/source/include/: mfs_rev.h mfs.h mfs_cnfg.h part_mgr.h mfs_prv.h
