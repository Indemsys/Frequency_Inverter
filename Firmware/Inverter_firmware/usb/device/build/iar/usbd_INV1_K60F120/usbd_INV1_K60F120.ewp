# IAR project usbd_INV1_K60F120.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../../../../../usb/host/source/host/khci; ../../../../../usb/host/source/host/ehci; ../../../../../usb/device/source/include/rtos; ../../../../../usb/device/source/include/khci; ../../../../../usb/device/source/include/ehci; ../../../../../usb/device/source/include; ../../../../../usb/device/source/classes/include; ../../../../../usb/common/include; ../../../../../mqx/source/tad; ../../../../../mqx/source/psp/cortex_m/cpu; ../../../../../mqx/source/psp/cortex_m/core/M4; ../../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../../mqx/source/psp/cortex_m; ../../../../../mqx/source/io/usb_dcd/polled; ../../../../../mqx/source/io/usb_dcd/int; ../../../../../mqx/source/io/usb_dcd; ../../../../../mqx/source/io/usb; ../../../../../mqx/source/io/timer; ../../../../../mqx/source/io/tfs; ../../../../../mqx/source/io/tchres; ../../../../../mqx/source/io/spi; ../../../../../mqx/source/io/serial; ../../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../../mqx/source/io/sdcard; ../../../../../mqx/source/io/sai/int; ../../../../../mqx/source/io/sai; ../../../../../mqx/source/io/rtc; ../../../../../mqx/source/io/pipe; ../../../../../mqx/source/io/pcflash; ../../../../../mqx/source/io/pccard; ../../../../../mqx/source/io/pcb/mqxa; ../../../../../mqx/source/io/pcb; ../../../../../mqx/source/io/nandflash/nfc; ../../../../../mqx/source/io/nandflash; ../../../../../mqx/source/io/lwgpio; ../../../../../mqx/source/io/lpm; ../../../../../mqx/source/io/io_null; ../../../../../mqx/source/io/io_mem; ../../../../../mqx/source/io/io_dun; ../../../../../mqx/source/io/i2c/polled; ../../../../../mqx/source/io/i2c/int; ../../../../../mqx/source/io/i2c; ../../../../../mqx/source/io/hwtimer; ../../../../../mqx/source/io/gpio/kgpio; ../../../../../mqx/source/io/gpio; ../../../../../mqx/source/io/flashx/freescale; ../../../../../mqx/source/io/flashx; ../../../../../mqx/source/io/esdhc; ../../../../../mqx/source/io/enet/phy; ../../../../../mqx/source/io/enet/macnet; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/debug; ../../../../../mqx/source/io/crc; ../../../../../mqx/source/io/cm; ../../../../../mqx/source/io/can/flexcan; ../../../../../mqx/source/io/adc/kadc; ../../../../../mqx/source/io/adc; ../../../../../mqx/source/include; ../../../../../mqx/source/bsp/INV1_K60F120; ../../../../../config/INV1_K60F120; ../../../../../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  postbuild: "../../../../../usb/device/build/bat/usbd_INV1_K60F120.bat" "../../../../.." "../../../../../lib/INV1_K60F120.iar/debug/usb" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../../usb/device/build/bat/usbd_INV1_K60F120.bat" "../../../../.." "../../../../../lib/INV1_K60F120.iar/release/usb" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group USB Low Level Driver/ehci
    ../../../../../usb/host/source/host/ehci/: ehci_prv.h
    ../../../../../usb/device/source/include/ehci/: ehci_usbprv.h ehci_dev_main.h
    ../../../../../usb/device/source/device/ehci/: callback_ehci.c ehci_dev_main.c
  group USB Low Level Driver/khci
    ../../../../../usb/device/source/device/khci/: khci_dev_main.c callback_khci.c
    ../../../../../usb/host/source/host/khci/: khci_prv.h
    ../../../../../usb/device/source/include/khci/: khci_dev_main.h khci_usbprv.h
  group USB Device/source
    ../../../../../usb/device/source/device/: dev_shut.c dev_cncl.c dev_ep_deinit.c dev_recv.c dev_send.c dev_utl.c dev_main.c
  group USB Device/include
    ../../../../../usb/common/include/: usb_types.h usb.h usb_misc.h usb_desc.h usb_misc_prv.h usb_debug.h usb_prv.h usb_error.h
    ../../../../../usb/device/source/classes/include/: usb_stack_config.h
    ../../../../../usb/device/source/include/: devapi.h dev_main.h dev_cnfg.h
  group USB Device/os
    ../../../../../usb/device/source/include/rtos/: mqx_dev.h
  group USB Class Drivers/hid
    ../../../../../usb/device/source/classes/hid/: usb_hid.c
    ../../../../../usb/device/source/classes/include/: usb_hid.h
  group USB Class Drivers/usb_class
    ../../../../../usb/device/source/classes/include/: usb_class.h
    ../../../../../usb/device/source/classes/common/: usb_class.c
  group USB Class Drivers/msd
    ../../../../../usb/device/source/classes/msd/: usb_msc_scsi.c usb_msc.c
    ../../../../../usb/device/source/classes/include/: usb_msc.h usb_msc_scsi.h
  group USB Class Drivers/phdc
    ../../../../../usb/device/source/classes/phdc/: usb_phdc.c
    ../../../../../usb/device/source/classes/include/: usb_phdc.h
  group USB Class Drivers/cdc
    ../../../../../usb/device/source/classes/cdc/: usb_cdc_pstn.c usb_cdc.c
    ../../../../../usb/device/source/classes/include/: usb_cdc.h usb_cdc_pstn.h
  group USB Class Drivers/audio
    ../../../../../usb/device/source/classes/audio/: usb_audio.c
    ../../../../../usb/device/source/classes/include/: usb_audio.h
  group USB Class Drivers/framework
    ../../../../../usb/device/source/classes/include/: usb_framework.h
    ../../../../../usb/device/source/classes/common/: usb_framework.c
