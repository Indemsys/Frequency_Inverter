# IAR project usbh_INV1_K60F120.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../../../../../usb/host/source/rtos/mqx; ../../../../../usb/host/source/include; ../../../../../usb/host/source/host/khci; ../../../../../usb/host/source/host/ehci; ../../../../../usb/host/source/classes/printer; ../../../../../usb/host/source/classes/phdc; ../../../../../usb/host/source/classes/msd/mfs; ../../../../../usb/host/source/classes/msd; ../../../../../usb/host/source/classes/hub; ../../../../../usb/host/source/classes/hid; ../../../../../usb/host/source/classes/cdc; ../../../../../usb/host/source/classes/audio; ../../../../../usb/common/include; ../../../../../mqx/source/tad; ../../../../../mqx/source/psp/cortex_m/cpu; ../../../../../mqx/source/psp/cortex_m/core/M4; ../../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../../mqx/source/psp/cortex_m; ../../../../../mqx/source/io/usb_dcd/polled; ../../../../../mqx/source/io/usb_dcd/int; ../../../../../mqx/source/io/usb_dcd; ../../../../../mqx/source/io/usb; ../../../../../mqx/source/io/timer; ../../../../../mqx/source/io/tfs; ../../../../../mqx/source/io/tchres; ../../../../../mqx/source/io/spi; ../../../../../mqx/source/io/serial; ../../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../../mqx/source/io/sdcard; ../../../../../mqx/source/io/sai/int; ../../../../../mqx/source/io/sai; ../../../../../mqx/source/io/rtc; ../../../../../mqx/source/io/pipe; ../../../../../mqx/source/io/pcflash; ../../../../../mqx/source/io/pccard; ../../../../../mqx/source/io/pcb/mqxa; ../../../../../mqx/source/io/pcb; ../../../../../mqx/source/io/nandflash/nfc; ../../../../../mqx/source/io/nandflash; ../../../../../mqx/source/io/lwgpio; ../../../../../mqx/source/io/lpm; ../../../../../mqx/source/io/io_null; ../../../../../mqx/source/io/io_mem; ../../../../../mqx/source/io/io_dun; ../../../../../mqx/source/io/i2c/polled; ../../../../../mqx/source/io/i2c/int; ../../../../../mqx/source/io/i2c; ../../../../../mqx/source/io/hwtimer; ../../../../../mqx/source/io/gpio/kgpio; ../../../../../mqx/source/io/gpio; ../../../../../mqx/source/io/flashx/freescale; ../../../../../mqx/source/io/flashx; ../../../../../mqx/source/io/esdhc; ../../../../../mqx/source/io/enet/phy; ../../../../../mqx/source/io/enet/macnet; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/debug; ../../../../../mqx/source/io/crc; ../../../../../mqx/source/io/cm; ../../../../../mqx/source/io/can/flexcan; ../../../../../mqx/source/io/adc/kadc; ../../../../../mqx/source/io/adc; ../../../../../mqx/source/include; ../../../../../mqx/source/bsp/INV1_K60F120; ../../../../../config/INV1_K60F120; ../../../../../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  postbuild: "../../../../../usb/host/build/bat/usbh_INV1_K60F120.bat" "../../../../.." "../../../../../lib/INV1_K60F120.iar/debug/usb" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../../usb/host/build/bat/usbh_INV1_K60F120.bat" "../../../../.." "../../../../../lib/INV1_K60F120.iar/release/usb" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group USB Class Drivers/msd
    ../../../../../usb/host/source/classes/msd/mfs/: usbmfs.h usbmfs.c usbmfspr.h
    ../../../../../usb/host/source/classes/msd/: usb_host_msd_bo.h usb_host_msd_ufi.c usb_host_msd_queue.c usb_host_msd_ufi.h usb_host_msd_bo.c
  group USB Class Drivers/hub
    ../../../../../usb/host/source/classes/hub/: usb_host_hub_sm.c usb_host_hub.h usb_host_hub.c usb_host_hub_prv.h usb_host_hub_sm.h
  group USB Class Drivers/cdc
    ../../../../../usb/host/source/classes/cdc/: usb_host_cdc.h usb_host_cdc.c usb_host_cdc_intf.c
  group USB Class Drivers/audio
    ../../../../../usb/host/source/classes/audio/: usb_host_audio.c usb_host_audio_intf.c usb_host_audio.h
  group USB Class Drivers/phdc
    ../../../../../usb/host/source/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group USB Class Drivers/hid
    ../../../../../usb/host/source/classes/hid/: usb_host_hid.c usb_host_hid.h
  group USB Class Drivers/printer
    ../../../../../usb/host/source/classes/printer/: usb_host_printer.h usb_host_printer.c
  group USB Host/include
    ../../../../../usb/host/source/include/: host_dev_list.h host_cnfg.h host_snd.h host_shut.h host_common.h host_close.h host_cnl.h host_main.h host_ch9.h host_rcv.h hostapi.h
    ../../../../../usb/common/include/: usb.h usb_misc.h usb_desc.h usb_misc_prv.h usb_debug.h usb_prv.h usb_error.h usb_types.h
  group USB Host/source
    ../../../../../usb/host/source/host/: host_shut.c host_common.c host_close.c host_rcv.c host_snd.c host_cnl.c host_ch9.c host_dev_list.c host_main.c
  group USB Host/os
    ../../../../../usb/host/source/rtos/mqx/: mqx_dll.h usb_mqx.c mqx_host.h usb_mqx.h mqx_dll.c
  group USB Low Level Driver/ehci
    ../../../../../usb/host/source/host/ehci/: ehci_main.c ehci_iso.h ehci_intr.c ehci_iso.c ehci_utl.c ehci_intr.h ehci_bw.h ehci_cache.h ehci_shut.h ehci_main.h ehci_bw.c ehci_cncl.h ehci_utl.h ehci_cncl.c ehci.h ehci_shut.c
  group USB Low Level Driver/khci
    ../../../../../usb/host/source/host/khci/: khci.h khci.c
